# Keil uVision project main_LPC1758.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: LPC1758 NXP
  pack: Keil.LPC1700_DFP.2.6.0
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: main +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: _KEIL,LPC1758,_MCU_TYPE_LPC1758, USE_GRAPHIC_DISPLAY
  c include: .\Src;..\EmbSysLib\Src;..\EmbSysLib\Src\MCU\LPC17xx
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Src
    Src/: main.cpp
    ./Src/: VirtualTouchButton.cpp Subject.cpp Observer.cpp SoundPlayer.cpp Song.cpp SongPlayer.cpp Tone.cpp Navigation.cpp SoundButton.cpp UI.cpp KeyboardView.cpp InputEvents.cpp SongPlayerView.cpp
  group Lib
    ../EmbSysLib/Src/: lib.cpp lib.h
    ../EmbSysLib/Src/MCU/LPC17xx/Sys/Keil/: startup_LPC17xx.s RTOS_Asm.s
    ../EmbSysLib/Src/Module/: RTOS.h RTOS.cpp
    ../EmbSysLib/Src/Peripheral/: Disp_SPFD5408Bspi.h Disp_SPFD5408Bspi.cpp Touch_STMPE811i2c.h Touch_STMPE811i2c.cpp
  group Include
    ./Include/: VirtualTouchButton.h Observer.h Subject.h SoundPlayer.h Song.h SongPlayer.h Tone.h Navigation.h SoundButton.h UI.h KeyboardView.h InputEvents.h SongPlayerView.h
software components: CMSIS:CORE 5.0.1, CMSIS:DSP 1.5.1
